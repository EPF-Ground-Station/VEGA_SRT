options:
  parameters:
    generate_options: no_gui
    id: run_observation
    output_language: python
    run_options: run
  states: {}

blocks:
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*channels)
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/channels)
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: channels
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: channels
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: channels*3
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: channels*2
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: channels
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: obs_file
    type: float
    vlen: channels
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: raw_file
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(duration*bandwidth)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(t_sample*bandwidth/channels)
    type: float
    vlen: channels
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-channels:]
    type: complex
    vlen: channels
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*channels:3*channels]
    type: complex
    vlen: channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[channels:2*channels]
    type: complex
    vlen: channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:channels]
    type: complex
    vlen: channels
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: channels
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: channels
    type: complex
  states: {}
- name: channels
  id: parameter
  parameters:
    type: intx
    value: '1024'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: duration
  id: parameter
  parameters:
    type: eng_float
    value: '60'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: channels
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(channels)
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 1420e6
  states: {}
- name: if_gain
  id: parameter
  parameters:
    type: eng_float
    value: '20'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: obs_file
  id: parameter
  parameters:
    type: str
    value: observation.dat
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: dev_args
    bb_gain0: bb_gain
    freq0: frequency
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: bandwidth
    sync: sync
    type: fc32
  states: {}
- name: raw_file
  id: parameter
  parameters:
    type: str
    value: raw.dat
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    type: eng_float
    value: '30'
  states: {}
- name: t_sample
  id: parameter
  parameters:
    type: intx
    value: '1'
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_head_0, '0', blocks_delay_0, '0']
- [blocks_head_0, '0', blocks_delay_0_0, '0']
- [blocks_head_0, '0', blocks_delay_0_1, '0']
- [blocks_head_0, '0', blocks_file_sink_1, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
